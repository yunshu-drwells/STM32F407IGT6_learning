# Keil uVision project USB_Host_Msc_FATFS.uvprojx, settings and files
target USB_Host_Msc_FATFS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: USB_Host_Msc_FATFS
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_USB_OTG_FS
  c include: ../Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;  ../Drivers/CMSIS/Include;  ..\Middlewares\USB\STM32_USB_Host_Library\Core\Inc;  ..\Middlewares\USB\STM32_USB_Host_Library\Class\MSC\Inc;  ..\Middlewares\USB\USB_APP;  ..\Middlewares\FATFS\source;  ..\Middlewares\FATFS\exfuns
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c main.c stm32f4xx_it.c usb_otg.c gpio.c fsmc.c usart.c delay.c lcd.c malloc.c norflash.c spi.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_gpio.c stm32f4xx_hal_sram.c stm32f4xx_ll_usb.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_hcd.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c
  group Middlewares/USB_CORE
    ../Middlewares/USB/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Middlewares/USB_CLASS
    ../Middlewares/USB/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/USB_APP
    ../Middlewares/USB/USB_APP/: usbh_conf.c usbh_diskio_dma.c
  group Middlewares/FATFS
    ../Middlewares/FATFS/source/: diskio.c ff.c ffsystem.c ffunicode.c
    ../Middlewares/FATFS/exfuns/: exfuns.c fattester.c
